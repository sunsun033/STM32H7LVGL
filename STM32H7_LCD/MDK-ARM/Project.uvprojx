# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Hardware;../UI;..\Component\LVGL;..\Component\LVGL\lvgl;..\Component\LVGL\lvgl\src\drivers\display\st_ltdc;..\Component\LVGL\port
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma2d.c fmc.c i2c.c ltdc.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Hardware
    ../Hardware/: gt911.c i2c_bus.c lcd.c sdram.c
  group Component/LVGL/port
    ../Component/LVGL/port/: lv_port.c lv_port_disp.c lv_port_indev.c
  group Component/LVGL/core
    ../Component/LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group Component/LVGL/display
    ../Component/LVGL/lvgl/src/display/: lv_display.c
  group Component/LVGL/draw
    ../Component/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Component/LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Component/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group Component/LVGL/drivers
    ../Component/LVGL/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
  group Component/LVGL/font
    ../Component/LVGL/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Component/LVGL/indev
    ../Component/LVGL/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group Component/LVGL/layouts
    ../Component/LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../Component/LVGL/lvgl/src/layouts/grid/: lv_grid.c
    ../Component/LVGL/lvgl/src/layouts/: lv_layout.c
  group Component/LVGL
    ../Component/LVGL/lvgl/src/: lv_init.c
  group Component/LVGL/misc
    ../Component/LVGL/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
    ../Component/LVGL/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Component/LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Component/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group Component/LVGL/osal
    ../Component/LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group Component/LVGL/others
    ../Component/LVGL/lvgl/src/others/observer/: lv_observer.c
    ../Component/LVGL/lvgl/src/others/sysmon/: lv_sysmon.c
  group Component/LVGL/stdlib
    ../Component/LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Component/LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Component/LVGL/lvgl/src/stdlib/: lv_mem.c
    ../Component/LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Component/LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Component/LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group Component/LVGL/themes
    ../Component/LVGL/lvgl/src/themes/default/: lv_theme_default.c
    ../Component/LVGL/lvgl/src/themes/: lv_theme.c
    ../Component/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Component/LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
  group Component/LVGL/tick
    ../Component/LVGL/lvgl/src/tick/: lv_tick.c
  group Component/LVGL/widgets
    ../Component/LVGL/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Component/LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Component/LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../Component/LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../Component/LVGL/lvgl/src/widgets/button/: lv_button.c
    ../Component/LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Component/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Component/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Component/LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../Component/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Component/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Component/LVGL/lvgl/src/widgets/image/: lv_image.c
    ../Component/LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Component/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Component/LVGL/lvgl/src/widgets/label/: lv_label.c
    ../Component/LVGL/lvgl/src/widgets/led/: lv_led.c
    ../Component/LVGL/lvgl/src/widgets/line/: lv_line.c
    ../Component/LVGL/lvgl/src/widgets/list/: lv_list.c
    ../Component/LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Component/LVGL/lvgl/src/widgets/menu/: lv_menu.c
    ../Component/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Component/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Component/LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Component/LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../Component/LVGL/lvgl/src/widgets/scale/: lv_scale.c
    ../Component/LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../Component/LVGL/lvgl/src/widgets/span/: lv_span.c
    ../Component/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Component/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Component/LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../Component/LVGL/lvgl/src/widgets/table/: lv_table.c
    ../Component/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Component/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Component/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Component/LVGL/lvgl/src/widgets/win/: lv_win.c
  group Component/LVGL/libs
    ../Component/LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group UI
    ../UI/: ui.c img_background.c img_light.c
software components: CMSIS:CORE 4.3.0
